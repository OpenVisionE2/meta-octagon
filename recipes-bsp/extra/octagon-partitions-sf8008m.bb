require octagon-partitions.inc

SRCDATE = "20200615"

COMPATIBLE_MACHINE = "^(sf8008m)$"

SRC_URI[md5sum] = "1fc596fe2e89e2465515ca431206a610"
SRC_URI[sha256sum] = "10dec867e44c7ef59b1a18dac0e70f1f139c950935a825003ac533b8401bc0d4"


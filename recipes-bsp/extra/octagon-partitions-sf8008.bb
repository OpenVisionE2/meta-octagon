require octagon-partitions.inc

SRCDATE = "20201218"

COMPATIBLE_MACHINE = "^(sf8008)$"

SRC_URI[md5sum] = "f92310c9469b521d720db8d316764291"
SRC_URI[sha256sum] = "9d000a51e751e6309290263e14769e31a4956736e4676702c52f54f8ae1be52c"

SRCDATE = "20201207"

require octagon-dvb-modules-hisi.inc

COMPATIBLE_MACHINE = "^(sf8008m)$"

SRC_URI[md5sum] = "92ddec6a596b3d4bceb622f5ad599542"
SRC_URI[sha256sum] = "a7806df2204a95c14ee75a87962ba9bb9c9b26e7670ac890d68824aafec8f12b"

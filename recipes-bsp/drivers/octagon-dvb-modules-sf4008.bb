SRCDATE = "20180328"

COMPATIBLE_MACHINE = "^(sf4008)$"

require octagon-dvb-modules.inc

SRC_URI[md5sum] = "be836c2ddb1968a0d8233d256ea712ab"
SRC_URI[sha256sum] = "4520e2d85c2794410d140642cd5465332235cdc9619d8744529b16b8059dda98"

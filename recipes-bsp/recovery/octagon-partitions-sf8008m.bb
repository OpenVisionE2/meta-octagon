require octagon-partitions.inc

SRCDATE = "20201218"

COMPATIBLE_MACHINE = "^(sf8008m)$"

SRC_URI[md5sum] = "71b8eb141c1151b635ed722648863ab3"
SRC_URI[sha256sum] = "70d92198caeb82a8685f30b77f74d63dcc869fdf56d569aaf11e24c93f7d3333"
